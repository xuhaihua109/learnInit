# IAR project SysTick.ewp, settings and files
configuration SysTick (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F3_Discovery; C:\sw\STM32F303VC\Git_Repo\ST_discovery\STM32F3-Discovery_FW_V1.1.0\STM32F3-Discovery_FW_V1.1.0\Project\Peripheral_Examples\SysTick_Example\uCOS-II; C:\sw\STM32F303VC\Git_Repo\ST_discovery\STM32F3-Discovery_FW_V1.1.0\STM32F3-Discovery_FW_V1.1.0\Project\Peripheral_Examples\SysTick_Example\uCOS-II; C:\sw\STM32F303VC\Git_Repo\ST_discovery\STM32F3-Discovery_FW_V1.1.0\STM32F3-Discovery_FW_V1.1.0\Project\Peripheral_Examples\SysTick_Example\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; C:\sw\STM32F303VC\Git_Repo\ST_discovery\STM32F3-Discovery_FW_V1.1.0\STM32F3-Discovery_FW_V1.1.0\Project\Peripheral_Examples\SysTick_Example\uCOS-II\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SysTick.srec
  ILINK.IlinkOutputFile: SysTick.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
  group STM32F3-Discovery
    ../../../../Utilities/STM32F3_Discovery/: stm32f3_discovery.c
  group STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c
  group uCOS_ports
    ../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS_source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group User
    ../: app_cfg.c app_cfg.h main.c os_cfg.h stm32f30x_it.c system_stm32f30x.c
